# Keil uVision project mcu_specific_header.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mcu_specific_header
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: TM4C123xx.h test.c extra_space.txt TM4C123xxGPIO_DRIVER.h TM4C123xxGPIO_DRIVER.c nov18_01_led_test.c nov18_02_led_test.c nov18_03_ledtest.c nov18_04_led_blink.c nov18_05_pin_read.c nov23_01_interrupt.c nov23_00_test.c dec12__00_interrupt.c idle.c dec14_00_interrupt.c dec15_00_interrupt_working.c TM4C123xxSSI_DRIVER.h TM4C123xxSSI_DRIVER.c dec18_00__interrupt.c dec31__00_spi_api_build_test.c Jan01__00_spi_tiva_to_uno.c jan05__00_spi_tiva_to_arduino.c jan05__01_spi_tiva_to_arduino_with_commands.c jan06__00_spi_tiva_slave.c jan06__01_spi_tiva_slave_with_command_action.c jan12__00_spi_master_with_interrupt.c TM4C123xxI2C_DRIVER.c TM4C123xxI2C_DRIVER.h Jan19__00_i2c_build_test.c Jan19__01_i2c_send_byte_test.c Feb02__01_I2Cslave_rx_and_blink.c GPIO_PINS.h GPIO_PINS.c Feb03__01_spi_test_master.c thingsToDo.txt Feb03__02_spi_test_slave.c Feb03__99_check.c Feb03__03_spi_master_sequence.c Feb03__04_spi_slave_sequence.c Feb04__01_spi_bidirectional_transfer_01.c Feb04__02_spi_bidirectional_transfer_02.c Feb04__03_spi_bi_dir_with_intr01.c Feb04__04_spi_bi_dir_with_intr02.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
